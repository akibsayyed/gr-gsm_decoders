<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_recv</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e6/100</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/piotr/Odbiornik_gsm/test.bcch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>fc</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.9.2</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>gain0</key><value>g</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>gsm_receiver_hier</key>
<param><key>id</key><value>gsm_receiver_hier_0</value></param>
<param><key>input_rate</key><value>samp_rate_receiver</value></param>
<param><key>osr</key><value>4</value></param>
<param><key>arfcn</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>g</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>28</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>samp_rate_receiver</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>min</key><value>0.6e6</value></param>
<param><key>max</key><value>1.4e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>gsm_get_ccch_bursts</key>
<param><key>id</key><value>gsm_get_ccch_bursts_0</value></param>
</block>
<block>
<key>gsm_bursts_printer</key>
<param><key>id</key><value>gsm_bursts_printer_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>gsm_decoders_ccch_decoder</key>
<param><key>id</key><value>gsm_decoders_ccch_decoder_0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>938.4e6</value></param>
<param><key>min</key><value>800e6</value></param>
<param><key>max</key><value>1000e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<connection><source_block_id>gsm_get_ccch_bursts_0</source_block_id><sink_block_id>gsm_bursts_printer_0</sink_block_id><source_key>bursts_out</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_hier_0</source_block_id><sink_block_id>gsm_get_ccch_bursts_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts_in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gsm_receiver_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_get_ccch_bursts_0</source_block_id><sink_block_id>gsm_decoders_ccch_decoder_0</sink_block_id><source_key>bursts_out</source_key><sink_key>bursts_in</sink_key></connection>
</flow_graph>
