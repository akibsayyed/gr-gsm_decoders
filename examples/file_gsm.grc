<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>gsm_receiver_hier</key>
<param><key>id</key><value>gsm_receiver_hier_0</value></param>
<param><key>input_rate</key><value>samp_rate</value></param>
<param><key>osr</key><value>4</value></param>
<param><key>arfcn</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1625000/6*4</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>file_gsm</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>gsm_get_ccch_bursts</key>
<param><key>id</key><value>gsm_get_ccch_bursts_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/piotr/Odbiornik_gsm/programy grc/reconstr_signal</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>gsm_decoders_ccch_decoder</key>
<param><key>id</key><value>gsm_decoders_ccch_decoder_0</value></param>
</block>
<block>
<key>gsm_bursts_printer</key>
<param><key>id</key><value>gsm_bursts_printer_0</value></param>
</block>
<connection><source_block_id>gsm_receiver_hier_0</source_block_id><sink_block_id>gsm_get_ccch_bursts_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts_in</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>gsm_receiver_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_get_ccch_bursts_0</source_block_id><sink_block_id>gsm_decoders_ccch_decoder_0</sink_block_id><source_key>bursts_out</source_key><sink_key>bursts_in</sink_key></connection>
<connection><source_block_id>gsm_get_ccch_bursts_0</source_block_id><sink_block_id>gsm_bursts_printer_0</sink_block_id><source_key>bursts_out</source_key><sink_key>bursts</sink_key></connection>
</flow_graph>
